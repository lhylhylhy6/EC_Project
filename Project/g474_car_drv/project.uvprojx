# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32G474xx
  c include: board;rt-thread\components\drivers\include;libraries\STM32G4xx_HAL\CMSIS\Device\ST\STM32G4xx\Include;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\libc\posix\io\stdio;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\sensor;rt-thread\components\libc\compilers\common\extension;libraries\STM32G4xx_HAL\STM32G4xx_HAL_Driver\Inc;rt-thread\libcpu\arm\common;rt-thread\components\libc\compilers\common\extension\fcntl\octal;applications;rt-thread\components\drivers\spi;.;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\include;rt-thread\components\libc\posix\ipc;libraries\HAL_Drivers\config;libraries\HAL_Drivers;board\CubeMX_Config\Inc;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;rt-thread\libcpu\arm\cortex-m4
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: encoder_test.c main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c pulse_encoder.c rt_drv_pwm.c
    rt-thread/components/drivers/sensor/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/CubeMX_Config/Src/: stm32g4xx_hal_msp.c
    board/: board.c
    libraries/STM32G4xx_HAL/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_pulse_encoder.c drv_pwm.c drv_spi.c drv_tim.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/STM32G4xx_HAL/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_dma_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_cryp_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cryp.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_dma.c stm32g4xx_hal_uart.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_crc.c stm32g4xx_hal_usart.c stm32g4xx_hal_lptim.c stm32g4xx_hal_spi.c
    libraries/STM32G4xx_HAL/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
